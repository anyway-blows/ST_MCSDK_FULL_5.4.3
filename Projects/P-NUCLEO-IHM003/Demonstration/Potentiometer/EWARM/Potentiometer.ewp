# IAR project Potentiometer.ewp, settings and files
configuration Potentiometer (ARM, debug)
  General.OGChipSelectEditMenu: STM32G431RB ST STM32G431RB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: ARM_MATH_CM4; USE_HAL_DRIVER; STM32G431xx
  ICCARM.CCIncludePath2: ../Inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Potentiometer.hex
  ILINK.IlinkOutputFile: Potentiometer.out
  ILINK.IlinkIcfFile: stm32g431xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32g431xx.s
  group Application/User
    ../Src/: main.c potentiometer.c
