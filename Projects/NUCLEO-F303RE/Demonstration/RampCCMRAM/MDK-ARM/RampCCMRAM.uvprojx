# Keil uVision project RampCCMRAM.uvprojx, settings and files
target RampCCMRAM (ARM-ADS)
  device: STM32F303RE STMicroelectronics
  pack: Keil.STM32F3xx_DFP.1.4.0
  cpu: IRAM(0x20000000-0x2000FFFF) IRAM2(0x10000000-0x10003FFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: RampCCMRAM
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 wLevel=2
  c define: ARM_MATH_CM4,USE_HAL_DRIVER,STM32F303xE,CCMRAM
  c include: ../Inc
  library: MicroLIB
  scatter file: .\STM32F303x.sct
  group Application/MDK-ARM
    ./: startup_stm32f303xe.s
  group Application/User
    ../Src/: ramp.c
software components: CMSIS:CORE 4.3.0
