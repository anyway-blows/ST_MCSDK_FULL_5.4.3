# IAR project DualDriveCCMRAM.ewp, settings and files
configuration DualDriveCCMRAM (ARM, debug)
  General.OGChipSelectEditMenu: STM32F303VE ST STM32F303VE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: ARM_MATH_CM4; USE_HAL_DRIVER; STM32F303xE; CCMRAM
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: DualDriveCCMRAM.bin
  ILINK.IlinkOutputFile: DualDriveCCMRAM.out
  ILINK.IlinkIcfFile: stm32f303xe_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32f303xe.s
  group Application/User
    ../Src/: main.c speed_ramp_for_dual_drive.c ui_task.c
